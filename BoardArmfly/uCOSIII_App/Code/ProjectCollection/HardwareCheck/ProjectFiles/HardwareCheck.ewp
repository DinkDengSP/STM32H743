# IAR project HardwareCheck.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; USE_HAL_DRIVER; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING
  ICCARM.CCIncludePath2: ..\..\..\CommonFunc; ..\..\..\CommonFunc\ADT; ..\..\..\CommonFunc\SystemUtil; ..\..\..\CommonService; ..\..\..\Driver\DriverCore\CMSIS; ..\..\..\Driver\DriverCore\CoreUtil; ..\..\..\Driver\DriverCore\HAL_Driver; ..\..\..\Driver\DriverCore\HAL_Driver\Inc; ..\..\..\Driver\DriverCore\HAL_Driver\Src; ..\..\..\Driver\DriverCore\HAL_DriverSupport; ..\..\..\Driver\DriverCore\Math; ..\..\..\Driver\DriverCore\Math\Lib; ..\..\..\Driver\DriverCore\Startup; ..\..\..\Driver\DriverCore\Startup\Linker; ..\..\..\Driver\DriverBoard; ..\..\..\Driver\DriverMCU; ..\..\..\ThirdParty\bget; ..\..\..\ThirdParty\STemWin; ..\..\..\ThirdParty\RTT; ..\..\..\uCOS_III\uC-CPU; ..\..\..\uCOS_III\uC-CPU\Ports; ..\..\..\uCOS_III\uC-LIB; ..\..\..\uCOS_III\uCOS-III; ..\..\..\uCOS_III\uCOS-III\Ports; ..\DriverConfig\BoardConfig; ..\DriverConfig\CoreConfig; ..\DriverConfig\OSConfig; ..\DriverConfig\OtherConfig; ..\DriverConfig\ThirdPartyConfig; ..\DriverConfig\UserConfig; ..\TaskMain; ..\TaskMain\ServiceSupport\ServiceImpl; ..\TaskMain\ServiceSupport\ServiceImpl\ServiceImplConfig; ..\TaskMain\ServiceSupport\ServiceIpc; ..\TaskMain\ServiceSupport\ServiceTask; ..\TaskMain\ServiceSupport\ServiceUtil; ..\TaskMain\ComplexSupport\ComplexImpl; ..\TaskMain\ComplexSupport\ComplexImpl\ComplexImplConfig; ..\TaskMain\ComplexSupport\ComplexIpc; ..\TaskMain\ComplexSupport\ComplexTask; ..\TaskMain\ComplexSupport\ComplexUtil; ..\TaskMain\AppSupport\AppImpl; ..\TaskMain\AppSupport\AppImpl\AppImplConfig; ..\TaskMain\AppSupport\AppIpc; ..\TaskMain\AppSupport\AppTask; ..\TaskMain\AppSupport\AppUtil
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HardwareCheck.hex
  ILINK.IlinkOutputFile: HardwareCheck.out
  ILINK.IlinkIcfFile: ..\..\..\Driver\DriverCore\Startup\Linker\stm32h743xI_Full.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CommonFunc/ADT
    ../../../CommonFunc/ADT/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h ADT_Inc.h ADT_Port.c ADT_Port.h
  group CommonFunc/SystemUtil
    ../../../CommonFunc/SystemUtil/: ErrorCode.c ErrorCode.h UserMemManage.c UserMemManage.h
  group Driver/DriverBoard
    ../../../Driver/DriverBoard/: BoardBeep.c BoardBeep.h BoardButton.c BoardButton.h BoardExtPort.c BoardExtPort.h BoardInc.h BoardIntMasterDMA.c BoardJoysTick.c BoardJoysTick.h BoardLed.c BoardLed.h BoardSD.c BoardSD.h BoardSDRAM.c BoardSDRAM.h BoardW25Q256.c BoardW25Q256.h BoardW25Q64.c BoardW25Q64.h
  group Driver/DriverCore/CMSIS
    ../../../Driver/DriverCore/CMSIS/: cmsis_iccarm.h cmsis_version.h core_cm7.h tz_context.h
  group Driver/DriverCore/CoreUtil
    ../../../Driver/DriverCore/CoreUtil/: CoreDelay.c CoreDelay.h CoreUtil.h CoreUtilOther.c
  group Driver/DriverCore/HAL_Driver/Inc
    ../../../Driver/DriverCore/HAL_Driver/Inc/: stm32_assert_template.h stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cec.h stm32h7xx_hal_comp.h stm32h7xx_hal_cordic.h stm32h7xx_hal_cortex.h stm32h7xx_hal_crc.h stm32h7xx_hal_crc_ex.h stm32h7xx_hal_cryp.h stm32h7xx_hal_cryp_ex.h stm32h7xx_hal_dac.h stm32h7xx_hal_dac_ex.h stm32h7xx_hal_dcmi.h stm32h7xx_hal_def.h stm32h7xx_hal_dfsdm.h stm32h7xx_hal_dfsdm_ex.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma2d.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_dsi.h stm32h7xx_hal_dts.h stm32h7xx_hal_eth.h stm32h7xx_hal_eth_ex.h stm32h7xx_hal_exti.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_fmac.h stm32h7xx_hal_gfxmmu.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hash.h stm32h7xx_hal_hash_ex.h stm32h7xx_hal_hcd.h stm32h7xx_hal_hrtim.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_i2s.h stm32h7xx_hal_i2s_ex.h stm32h7xx_hal_irda.h stm32h7xx_hal_irda_ex.h stm32h7xx_hal_iwdg.h stm32h7xx_hal_jpeg.h stm32h7xx_hal_lptim.h stm32h7xx_hal_ltdc.h stm32h7xx_hal_ltdc_ex.h stm32h7xx_hal_mdios.h stm32h7xx_hal_mdma.h stm32h7xx_hal_mmc.h stm32h7xx_hal_mmc_ex.h stm32h7xx_hal_nand.h stm32h7xx_hal_nor.h stm32h7xx_hal_opamp.h stm32h7xx_hal_opamp_ex.h stm32h7xx_hal_ospi.h stm32h7xx_hal_otfdec.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pssi.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_qspi.h stm32h7xx_hal_ramecc.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_rng.h stm32h7xx_hal_rng_ex.h stm32h7xx_hal_rtc.h stm32h7xx_hal_rtc_ex.h stm32h7xx_hal_sai.h stm32h7xx_hal_sai_ex.h stm32h7xx_hal_sd.h stm32h7xx_hal_sd_ex.h stm32h7xx_hal_sdram.h stm32h7xx_hal_smartcard.h stm32h7xx_hal_smartcard_ex.h stm32h7xx_hal_smbus.h stm32h7xx_hal_spdifrx.h stm32h7xx_hal_spi.h stm32h7xx_hal_spi_ex.h stm32h7xx_hal_sram.h stm32h7xx_hal_swpmi.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h stm32h7xx_hal_usart.h stm32h7xx_hal_usart_ex.h stm32h7xx_hal_wwdg.h stm32h7xx_ll_adc.h stm32h7xx_ll_bdma.h stm32h7xx_ll_bus.h stm32h7xx_ll_comp.h stm32h7xx_ll_cordic.h stm32h7xx_ll_cortex.h stm32h7xx_ll_crc.h stm32h7xx_ll_crs.h stm32h7xx_ll_dac.h stm32h7xx_ll_delayblock.h stm32h7xx_ll_dma.h stm32h7xx_ll_dma2d.h stm32h7xx_ll_dmamux.h stm32h7xx_ll_exti.h stm32h7xx_ll_fmac.h stm32h7xx_ll_fmc.h stm32h7xx_ll_gpio.h stm32h7xx_ll_hrtim.h stm32h7xx_ll_hsem.h stm32h7xx_ll_i2c.h stm32h7xx_ll_iwdg.h stm32h7xx_ll_lptim.h stm32h7xx_ll_lpuart.h stm32h7xx_ll_mdma.h stm32h7xx_ll_opamp.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_rng.h stm32h7xx_ll_rtc.h stm32h7xx_ll_sdmmc.h stm32h7xx_ll_spi.h stm32h7xx_ll_swpmi.h stm32h7xx_ll_system.h stm32h7xx_ll_tim.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_utils.h stm32h7xx_ll_wwdg.h
  group Driver/DriverCore/HAL_Driver/Src
    ../../../Driver/DriverCore/HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c
  group Driver/DriverCore/HAL_DriverSupport
    ../../../Driver/DriverCore/HAL_DriverSupport/: stm32h743xx.h stm32h7xx.h stm32h7xx_it.h system_stm32h7xx.h
  group Driver/DriverCore/Math
    ../../../Driver/DriverCore/Math/: arm_common_tables.h arm_const_structs.h arm_math.h
  group Driver/DriverCore/Math/Lib
    ../../../Driver/DriverCore/Math/Lib/: iar_cortexM7lf_math.a
  group Driver/DriverCore/Startup
    ../../../Driver/DriverCore/Startup/: startup_stm32h743xx.s
  group Driver/DriverCore/Startup/Linker
    ../../../Driver/DriverCore/Startup/Linker/: stm32h743xI_Full.icf
  group Driver/DriverMCU
    ../../../Driver/DriverMCU/: MCU_Common.h MCU_Inc.h MCU_MPU.c MCU_MPU.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_SPI.c MCU_SPI.h MCU_Uart.h MCU_Uart1.c MCU_UartInt.c MCU_UniqueID.c MCU_UniqueID.h MCU_WDG.c MCU_WDG.h
  group ProjectFiles/DriverConfig/CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC.h MPU_Config.c MPU_Config.h stm32h7xx_hal_conf.h stm32h7xx_it.c system_stm32h7xx.c
  group ProjectFiles/DriverConfig/OSConfig
    ../DriverConfig/OSConfig/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ProjectFiles/DriverConfig/UserConfig
    ../DriverConfig/UserConfig/: MemManageConfig.h
  group ProjectFiles/TaskMain
    ../TaskMain/: SystemMain.c SystemTaskConfig.h SystemTaskStart.c
  group ProjectFiles/TaskMain/AppSupport/AppTask
    ../TaskMain/AppSupport/AppTask/: AppTaskConfig.h
  group ProjectFiles/TaskMain/ComplexSupport/ComplexTask
    ../TaskMain/ComplexSupport/ComplexTask/: ComplexTaskConfig.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask
    ../TaskMain/ServiceSupport/ServiceTask/: ServiceTaskConfig.h ServiceTaskHeart.c
  group ThirdParty/bget
    ../../../ThirdParty/bget/: bget.c bget.h
  group ThirdParty/RTT
    ../../../ThirdParty/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group uCOS_III/uC-CPU
    ../../../uCOS_III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uCOS_III/uC-CPU/Ports
    ../../../uCOS_III/uC-CPU/Ports/: bsp_cpu.c cpu.h cpu_a.asm cpu_c.c
  group uCOS_III/uC-LIB
    ../../../uCOS_III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS_III/uCOS-III
    ../../../uCOS_III/uCOS-III/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group uCOS_III/uCOS-III/Ports
    ../../../uCOS_III/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_cpu_isr.asm
